<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\md_ib_exxus_4.ewp</path>
  </project>
  <batchBuild/>
</workspace>


